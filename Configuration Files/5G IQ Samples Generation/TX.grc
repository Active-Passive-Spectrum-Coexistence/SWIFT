options:
  parameters:
    author: ubuntu
    generate_options: qt_gui
    id: TX
    output_language: python
    title: Transmit
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 30.72e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/aerpaw/Desktop/SWIFT_exp_April_2024/wave_5slots/sampleschem4_2_1_-10_QPSK.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: 27e6
    fc: 1.4135e9
    fftsize: '2048'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: 27e06
    center_freq0: 1.4135e09
    dev_args: '""'
    gain0: '60'
    len_tag_name: ''
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
